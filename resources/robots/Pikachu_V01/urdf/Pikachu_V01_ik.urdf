Commit message: fix pikachu urdf & update train

File: resources/robots/Pikachu_V01/urdf/Pikachu_V01_ik.urdf (robot description, URDF)
Before this commit: robot Pikachu_V01, 14 links, 13 joints
Joints:
- joint left_knee_joint: axis 0 0 -1 -> 0 0 1
- joint right_knee_joint: axis 0 0 1 -> 0 0 -1
